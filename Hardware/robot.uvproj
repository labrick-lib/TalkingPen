# Keil uVision project robot.uvproj, settings and files
target robot (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: robot
  AfterMake: fromelf --bin ".\Debug\@L.axf" --output ".\Debug\@L.bin"
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: __N572_DEBUG_
  c include: .\ISD9XXX\Include;.\ISD9XXX\Include\Driver;.\ISD9XXX\CMSIS\CM0\CoreSupport;.\ISD9XXX\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;.\ISD9XXX\Include\Lib;.\driver;.\app;.\camera_drv;.\camera_drv_lib;.\include;.\source;.\adpcm;.\SDK\MV_EH;.\SDK\LibSiren7
  memory RVCT4: ROM 0x0 size 0x24400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\robot.scatter
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group app
    ./app/: main.c mystdio.c cam.c play.c esr.c icKey.c DRV_KEY.c timer.c led.c stat.h redirect.c ivTouchSense.c
    ./adpcm/: ivADPCM.c
  group driver
    ./driver/: pwm_drv.c icSystem.c icUART.c icSPI_opt.c i2c_drv.c icADC.c
  group System
    ./ISD9XXX/CMSIS/CM0/CoreSupport/: core_cm0.c
    ./ISD9XXX/CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
  group SystemDriver
    ./ISD9XXX/Src/Driver/: DrvSYS.c DrvDPWM.c DrvADC.c DrvALC.C DrvPDMA.c DrvGPIO.c DrvUART.c retarget.c DrvI2S.c DrvTimer.c DrvFMC.c DrvCapSense.c DrvACMP.C
  group obj
    ./camera_drv_lib/: capinterface.o find_point.o i2s_cam_get_data.o i2s_camera.o
    ./ISD9XXX/Lib/: SemiHost_Keil.lib
    ./SDK/MV_EH/: IMV_EH_M0_Lib_3.1.00.lib
    ./include/: Sdk_Esr_5.0.1009.lib
  group include
    ./include/: ESRRes.h ivConfig.h ivDefine.h ivEsErrorCode.h ivESR.h ivPlatform.h ESRResForVAD.h
  group libSiren7
    ./SDK/LibSiren7/: LibSiren7EnDec.c
    ./SDK/LibSiren7/common/: defs.h basop32.c basop32.h common.c count.h typedef.h huff_def.h huff_tab.c huff_tab.h tables.c tables.h
    ./SDK/LibSiren7/decode/: decoder.c coef2sam.c dct4_s.c dct4_s.h
target robot_rel (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: robot
  AfterMake: fromelf --bin ".\Reless\@L.axf" --output ".\Reless\@L.bin"
  c flags: Optim=3 oTime=1 OneElfS=1
  c include: .\ISD9XXX\Include;.\ISD9XXX\Include\Driver;.\ISD9XXX\CMSIS\CM0\CoreSupport;.\ISD9XXX\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;.\ISD9XXX\Include\Lib;.\SDK\esr;.\public;.\common;.\robot;.\driver;.\camera_drv_lib;.\SDK\MV_EH
  memory RVCT4: ROM 0x0 size 0x24400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\robot.scatter
  link misc: as above
